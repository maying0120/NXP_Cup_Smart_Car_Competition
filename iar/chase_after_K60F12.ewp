# IAR project chase_after_K60F12.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60FN1M0xxx12 Freescale MK60FN1M0xxx12
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: LPLD_K60; USE_K60F12
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\LPLD\FUNC; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: chase_after_K60F12.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60FX512xxx15 Freescale MK60FX512xxx15
  AARM.AUserIncludes: as above
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60FN1M0_FLASH.icf
configuration BOOT (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60FN1M0_BOOT.icf
  group app/c
    ../app/: Bluetooth.c Commun_Shift.c Dis_Calc.c hardware.c Island_Judge.c Keyboard.c Motor_Ctrl.c OLED.c Pit_5ms.c Ramp_Handle.c Rudder_Ctrl.c Spd_PID.c Spd_Set.c Ultra_Distance.c
  group app/h
    ../app/: Bluetooth.h Commun_Shift.h Dis_Calc.h hardware.h Includes.h Island_Judge.h Keyboard.h Motor_Ctrl.h OLED.h Pit_5ms.h Ramp_Handle.h Rudder_Ctrl.h SEEKFREE_IIC.h SEEKFREE_L3G4200D.h Spd_PID.h Spd_Set.h Ultra_Distance.h
  group app/main
    ../app/: chase_after.c k60_card.h
  group lib/common
    ../../../lib/common/: alloc.c assert.c assert.h common.h io.c io.h printf.c queue.c queue.h relocate.c relocate.h stdlib.c stdlib.h uif.c uif.h
  group lib/CPU
    ../../../lib/CPU/: startup_K60F12.s system_MK60.c
  group lib/LPLD
    ../../../lib/LPLD/: LPLD_Drivers.h
  group lib/LPLD/HW
    ../../../lib/LPLD/HW/: HW_ADC.c HW_ADC.h HW_DMA.c HW_DMA.h HW_FLASH.c HW_FLASH.h HW_FTM.c HW_FTM.h HW_GPIO.c HW_GPIO.h HW_I2C.c HW_I2C.h HW_LPTMR.c HW_LPTMR.h HW_MCG.c HW_MCG.h HW_NVIC.c HW_NVIC.h HW_PIT.c HW_PIT.h HW_UART.c HW_UART.h HW_WDOG.c HW_WDOG.h
